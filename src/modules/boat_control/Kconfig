## src/modules/boat_control/Kconfig
```kconfig
menuconfig MODULES_BOAT_CONTROL
	bool "boat_control"
	default n
	---help---
		Enable support for boat control.
```
